Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2024-03-04T14:44:57
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Mar 04 14:44:57 2024 * Host: SPOJAR-RO-LE * Database: C:\Users\spojar\AppData\Local\Temp\e76d8adb-b982-466a-9498-914558ec883a\0366dc1c-7402-4ef0-a904-0dc57043678e\ifc * Database version: 5507 * Database creation date: Mon Mar 04 14:44:52 2024 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Mon Mar 04 14:44:53 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Mar 04 14:44:53 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Pset_BuildingStoreyCommon - Reference: Level 1
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcAirTerminalBox: FLUX+ 275 Flat Vertical Mounted Right, VE_Exhaust Unit_F_MEPcontent_Renson_Flux+ 225-325 Flat_BE-EN:FLUX+ 275 Flat Vertical Mounted Right:10412
In: Level 1
Type - Material: Color RGB 030-030-030, Color RGB 043-043-044, Color RGB 145-145-145, Color RGB 138-110-075
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Drain Diameter: 32 mm; Duct Diameter: 160 mm; Height: 300 mm; Length: 1188 mm; Width: 745 mm
Type - Electrical - Hertz: 50 Hz; Voltage: 230 V
Type - Electrical Engineering - Phase: 1
Type - Identity Data - Article Description: Central, demand-driven ventilation unit with heat recovery; Article Type: FLUX+ 275 Flat Vertical Mounted Right; Base Family Version: 24.04; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Central, demand-driven ventilation unit with heat recovery; EMCS Version: 5.0; ETIM Article Class: EC010004; Family Version: 23.13; GLN: 5413470000008; GTIN: 5413470315386; Manufacturer: Renson; Manufacturer Art. No.: 76015034; Manufacturer URL: https://renson.net/nl-be; MEPcontent Class: EXHAUST_UNIT; Model: FLUX+ 275 Flat Vertical Mounted Right; OmniClass Number: 23.75.70.21.31; OmniClass Title: Exhaust Terminals; Product Line: Renson Flux+; Revit Version: 2020; Type Name: FLUX+ 275 Flat Vertical Mounted Right; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 043-043-044; Brown: Color RGB 138-110-075; Dark Black: Color RGB 030-030-030
Type - Mechanical - Loads - Airflow Rate (m3/h): 275; Unit Weight (kg): 25
Type - Other - Category: Mechanical Equipment; Connection Offset: 182.746 mm; EHA X Offset: 340 mm; EHA Y Offset: 102.5 mm; ETA X Offset: 760 mm; ETA Y Offset: 997.5 mm; Family Name: VE_Exhaust Unit_F_MEPcontent_Renson_Flux+ 225-325 Flat_BE-EN; Horizontal Body: no; Horizontal Left: no; Horizontal Right: no; ODA X Offset: 760 mm; ODA Y Offset: 102.5 mm; SUP X Offset: 340 mm; SUP Y Offset: 997.5 mm; Vertical Left: no; Vertical Right: yes
Type - Pset_AirTerminalBoxTypeCommon - Reference: FLUX+ 275 Flat Vertical Mounted Right
Type - Pset_EnvironmentalImpactIndicators - Reference: FLUX+ 275 Flat Vertical Mounted Right
Type - Pset_ManufacturerTypeInformation - Manufacturer: Renson
Pset_AirTerminalBoxTypeCommon - sets with these values: 2
Constraints - Elevation from Level: 0 mm
Dimensions - Area: 23.6886 m2; Volume: 0.802214 m3
Electrical - Power: 0 W
Identity Data - Mark: 1
Mechanical - System Classification: Supply Air,Exhaust Air,Supply Air,Sanitary
Mechanical - Flow - Drain Fixture Units: 0; Exhaust Air Flow 1: 0 m3/s; Exhaust Air Flow 2: 0 m3/s; Supply Air Flow 1: 0 m3/s; Supply Air Flow 2: 0 m3/s
Other - Drain Angle: 270 deg; Drain Ceiling Mounted Left Safe: no; Drain Ceiling Mounted Right Safe: no; Drain Connection Offset: 366.324 mm; Drain Wall Mounted Left Safe: no; Drain Wall Mounted Right Safe: no; Drain X Offset: 533 mm; Drain Y Offset: 350 mm; EHA Angle: 270 deg; ETA Angle: 90 deg; Family: VE_Exhaust Unit_F_MEPcontent_Renson_Flux+ 225-325 Flat_BE-EN: FLUX+ 275 Flat Vertical Mounted Right; Family and Type: VE_Exhaust Unit_F_MEPcontent_Renson_Flux+ 225-325 Flat_BE-EN: FLUX+ 275 Flat Vertical Mounted Right; ODA Angle: 270 deg; SUP Angle: 90 deg; Type: VE_Exhaust Unit_F_MEPcontent_Renson_Flux+ 225-325 Flat_BE-EN: FLUX+ 275 Flat Vertical Mounted Right; Type Id: VE_Exhaust Unit_F_MEPcontent_Renson_Flux+ 225-325 Flat_BE-EN: FLUX+ 275 Flat Vertical Mounted Right
Phasing - Phase Created: New Construction
Visibility - Back Clearance: 360 mm; Drain Ceiling Mounted Left: no; Drain Ceiling Mounted Right: no; EHA Connection: no; ETA Connection: no; Front Clearance: 360 mm; Left Clearance: 360 mm; ODA Connection: no; Right Clearance: 360 mm; Service Space: no; SUP Connection: no; Top Clearance: 360 mm

# IfcDistributionPort (5)
Description: Flow
Name | FlowDirection
3 x Port_10412 | SINK
2 x Port_10412 | SOURCE
