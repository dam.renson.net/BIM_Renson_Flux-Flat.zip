Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.1]
File name: 0001
Time: 2024-04-15T09:20:23
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20191106_1200(x64) - Exporter 20.2.1.1 - Alternate UI 20.2.1.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Apr 15 09:20:23 2024 * Host: RENSON-PC64rjMe * Database: C:\Users\naniw\AppData\Local\Temp\788b8dc0-3507-4075-be50-abb93b98315a\81b1ca70-37fa-478c-baf6-061493a67ad3\ifc * Database version: 5507 * Database creation date: Mon Apr 15 09:20:19 2024 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Mon Apr 15 09:20:19 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Apr 15 09:20:19 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: 8mm Head

# IfcAirTerminalBox: FLUX+ 370 Flat Horizontal Mounted Right, Renson_Flux+ 225-275-370 Flat:FLUX+ 370 Flat Horizontal Mounted Right:353354
In: Level 1
Type - Material: Color RGB 030-030-030, Color RGB 043-043-044, Color RGB 145-145-145, Color RGB 138-110-075
Type - Pset_AirTerminalBoxTypeCommon - Reference: FLUX+ 370 Flat Horizontal Mounted Right
Type - Pset_EnvironmentalImpactIndicators - Reference: FLUX+ 370 Flat Horizontal Mounted Right
Type - Pset_ManufacturerTypeInformation - Manufacturer: Renson
Pset_AirTerminalBoxTypeCommon - sets with these values: 2
